## boards/shields/cca/Kconfig.defconfig
```kconfig
if SHIELD_CCA

config ZMK_KEYBOARD_NAME
    default "Couch Clicker"

endif # SHIELD_CCA
```
